# IAR project sam_a5d2_xplained_ultra.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xplained_ultra; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xplained_ultra.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xplained_ultra\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xplained_ultra/: sam_a5d2_xplained_ultra.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/config/sam_a5d2_xplained_ultra/crypto/src/: aes.h arc4.h asn.h asn_public.h async.h camellia.h certs_test.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_rng_hw.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pic32mz-crypt.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h selftest.h settings.h sha.h sha256.h sha3.h sha512.h signature.h sniffer.h sniffer_error.h srp.h ssl.h tfm.h types.h version.h visibility.h wc_encrypt.h wc_pkcs11.h wc_port.h wolfevent.h wolfio.h wolfmath.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xplained_ultra/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_a5d2_xplained_ultra/crypto/src/zlib-1.2.7/: crc32.h deflate.h gzguts.h inffast.h inffixed.h inflate.h inftrees.h trees.h zconf.h zlib.h zutil.h
    ../src/config/sam_a5d2_xplained_ultra/crypto/: crypto.h
    ../src/config/sam_a5d2_xplained_ultra/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xplained_ultra/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xplained_ultra/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xplained_ultra/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xplained_ultra/system/console/: sys_console.h
    ../src/config/sam_a5d2_xplained_ultra/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xplained_ultra/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xplained_ultra/system/time/src/: sys_time_local.h
    ../src/config/sam_a5d2_xplained_ultra/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/config/sam_a5d2_xplained_ultra/crypto/src/zlib-1.2.7/: adler32.c crc32.c deflate.c inffast.c inflate.c inftrees.c trees.c zutil.c
    ../src/config/sam_a5d2_xplained_ultra/crypto/src/: aes.c arc4.c asm.c asn.c async.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c crypt_aes_sam6149.c crypt_rng_sam6334.c crypt_sha1_sam6156.c crypt_sha224_sam6156.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_sha_sam6156.c crypt_tdes_sam6150.c crypto.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xplained_ultra/: cstartup.s exceptions.c fault_handlers.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xplained_ultra/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xplained_ultra/peripheral/uart/: plib_uart1.c
    ../src/config/sam_a5d2_xplained_ultra/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xplained_ultra/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
    ../src/config/sam_a5d2_xplained_ultra/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xplained_ultra/system/time/src/: sys_time.c
