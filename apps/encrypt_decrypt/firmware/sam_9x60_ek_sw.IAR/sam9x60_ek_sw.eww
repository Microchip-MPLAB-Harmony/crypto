<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sam9x60_ek_sw.ewp</path>
    </project>
    <batchBuild />
</workspace>
