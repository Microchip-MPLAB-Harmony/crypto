<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sam_e70_xplained_ultra.ewp</path>
    </project>
    <batchBuild />
</workspace>
