# IAR project Backup of sam_9x6_ek_rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek_rtos; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x6_ek_rtos.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_9x60_ek_rtos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_9x60_ek_rtos/: sam_9x60_ek_rtos.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
    ../src/config/sam_9x60_ek_rtos/crypto/src/: aes.h arc4.h asn.h asn_public.h async.h camellia.h certs_test.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_rng_hw.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pic32mz-crypt.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h selftest.h settings.h sha.h sha256.h sha3.h sha512.h signature.h sniffer.h sniffer_error.h srp.h ssl.h tfm.h types.h version.h visibility.h wc_encrypt.h wc_pkcs11.h wc_port.h wolfevent.h wolfio.h wolfmath.h
    ../src/: app.h
    ../src/config/sam_9x60_ek_rtos/bsp/: bsp.h
    ../src/config/sam_9x60_ek_rtos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h toolchain_specifics.h user.h
    ../src/config/sam_9x60_ek_rtos/peripheral/mmu/: cp15.h plib_mmu.h
    ../src/config/sam_9x60_ek_rtos/crypto/src/zlib-1.2.7/: crc32.h deflate.h gzguts.h inffast.h inffixed.h inflate.h inftrees.h trees.h zconf.h zlib.h zutil.h
    ../src/third_party/rtos/FreeRTOS/Source/Include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../src/config/sam_9x60_ek_rtos/crypto/: crypto.h
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
    ../src/config/sam_9x60_ek_rtos/driver/: driver.h driver_common.h
    ../src/config/sam_9x60_ek_rtos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/config/sam_9x60_ek_rtos/peripheral/aic/: plib_aic.h
    ../src/config/sam_9x60_ek_rtos/peripheral/clk/: plib_clk.h
    ../src/config/sam_9x60_ek_rtos/peripheral/dbgu/: plib_dbgu.h plib_dbgu_common.h
    ../src/config/sam_9x60_ek_rtos/peripheral/pio/: plib_pio.h
    ../src/config/sam_9x60_ek_rtos/peripheral/pit/: plib_pit.h
    ../src/config/sam_9x60_ek_rtos/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
    ../src/config/sam_9x60_ek_rtos/system/cache/: sys_cache.h
    ../src/config/sam_9x60_ek_rtos/system/console/: sys_console.h
    ../src/config/sam_9x60_ek_rtos/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_9x60_ek_rtos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_rtos/system/time/src/: sys_time_local.h
    ../src/config/sam_9x60_ek_rtos/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/config/sam_9x60_ek_rtos/crypto/src/zlib-1.2.7/: adler32.c crc32.c deflate.c inffast.c inflate.c inftrees.c trees.c zutil.c
    ../src/config/sam_9x60_ek_rtos/crypto/src/: aes.c arc4.c asm.c asn.c async.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c crypt_aes_sam6149.c crypt_rng_sam6334.c crypt_sha1_sam6156.c crypt_sha224_sam6156.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_sha_sam6156.c crypt_tdes_sam6150.c crypto.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c
    ../src/: app.c main.c
    ../src/config/sam_9x60_ek_rtos/bsp/: bsp.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
    ../src/config/sam_9x60_ek_rtos/: cstartup.s exceptions.c freertos_hooks.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: FreeRTOS_tick_config.c port.c portASM.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_9x60_ek_rtos/stdio/: iar_monitor.c
    ../src/config/sam_9x60_ek_rtos/osal/: osal_freertos.c
    ../src/config/sam_9x60_ek_rtos/peripheral/aic/: plib_aic.c
    ../src/config/sam_9x60_ek_rtos/peripheral/clk/: plib_clk.c
    ../src/config/sam_9x60_ek_rtos/peripheral/dbgu/: plib_dbgu.c
    ../src/config/sam_9x60_ek_rtos/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_9x60_ek_rtos/peripheral/pio/: plib_pio.c
    ../src/config/sam_9x60_ek_rtos/peripheral/pit/: plib_pit.c
    ../src/config/sam_9x60_ek_rtos/peripheral/tc/: plib_tc0.c
    ../src/config/sam_9x60_ek_rtos/system/cache/: sys_cache.c
    ../src/config/sam_9x60_ek_rtos/system/console/src/: sys_console.c sys_console_local.h sys_console_uart.c sys_console_uart.h sys_console_uart_definitions.h
    ../src/config/sam_9x60_ek_rtos/system/int/src/: sys_int.c
    ../src/config/sam_9x60_ek_rtos/system/time/src/: sys_time.c
